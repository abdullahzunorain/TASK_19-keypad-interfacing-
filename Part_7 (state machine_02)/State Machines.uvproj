# Keil uVision project State Machines.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: State Machines +hex
  c flags: Optimize=8 SizeSpeed=1
  group New Group
    ./: CALCULATOR.c CALCULATOR.h LCD.c LCD.h main (2).c mainstate.c RTC.h TEMP.c TEMP.h 7sd.c
