# Keil uVision project task_19.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: task_19 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: 7sd.c calculator.c calculator.h lcd.c lcd.h main1.c main2.c mainstate.c RTC.h temp.c temp.h RTC.c
